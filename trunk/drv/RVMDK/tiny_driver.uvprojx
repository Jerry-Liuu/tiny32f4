# Keil uVision project tiny_driver.uvprojx, settings and files
target ADC_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,ADC_FLAG = 1
  c include: ..\CMSIS\Device\ST\STM32F4xx\Include;..\CMSIS\Include;..\USER\drv_inc;..\USER
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../USER/: main.c stm32fxxx_it.c
    ../USER/drv_src/: tiny_adc.c tiny_can.c tiny_counter.c tiny_dac.c tiny_gpio.c tiny_i2c.c tiny_pwm.c tiny_spi.c tiny_usart.c tiny_usb.c
  group TINYLIB
    ../TINYLIB/: TinyF4.lib
  group CIMIS
    ../CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
target CAN_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,CAN_FLAG = 1
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target CNT_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,CNT_FLAG = 1
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target DAC_TEST (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,DAC_FLAG = 1
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target GPIO_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,GPIO_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target I2C_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,I2C_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target PWM_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,PWM_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x15000
  memory RVCT10: RAM 0x10000000 size 0x10000
target SPI_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,SPI_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x16000
  memory RVCT10: RAM 0x10000000 size 0x10000
target USART_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USART_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x16000
  memory RVCT10: RAM 0x10000000 size 0x10000
target USB_TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: as above
  output: tinyf4
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USB_FLAG
  c include: as above
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20009000 size 0x16000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.2.0
